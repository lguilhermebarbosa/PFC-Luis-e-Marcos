options:
  parameters:
    author: Marcos
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Analisador_ Frequencia
  states: {}

blocks:
- name: frequencia
  id: variable
  parameters:
    value: '2412000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 80e6
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate/2000
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: frequencia
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: frequencia
    fftsize: '1024'
    rate: '0.5'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: frequencia
    dev_addr: '"adr=192.168.10.1"'
    gain0: '20'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', blocks_throttle2_0, '0']
- [uhd_usrp_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
